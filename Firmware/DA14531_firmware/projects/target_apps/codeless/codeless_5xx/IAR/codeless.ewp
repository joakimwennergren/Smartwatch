# IAR project codeless.ewp, settings and files
configuration codeless_585 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CODELESS_585; __DA14585__
  ICCARM.PreInclude: preinclude.h
  ICCARM.CCIncludePath2: ..\src; ..\src\config; ..\..\common_codeless_files\profiles\CLS\custom_profile; ..\..\sw_version; ..\..\..\..\..\sdk6\sdk\app_modules\api; ..\..\..\..\..\sdk6\sdk\ble_stack\controller\em; ..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc; ..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld; ..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm; ..\..\..\..\..\sdk6\sdk\ble_stack\ea\api; ..\..\..\..\..\sdk6\sdk\ble_stack\em\api; ..\..\..\..\..\sdk6\sdk\ble_stack\hci\api; ..\..\..\..\..\sdk6\sdk\ble_stack\hci\src; ..\..\..\..\..\sdk6\sdk\ble_stack\host\att; ..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc; ..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm; ..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gap; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc; ..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm; ..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc; ..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm; ..\..\..\..\..\sdk6\sdk\ble_stack\host\smp; ..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc; ..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anc\ancc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp\anps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\basc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcsc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bcs\bcss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\blp\blps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmsc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bms\bmss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cppc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp\cpps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp\cscps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctsc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cts\ctss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\disc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findl\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findt\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\gatt\gatt_client\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\glp\glps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpbh\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogpd\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hogp\hogprh\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp\hrps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\htp\htpt\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lanc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan\lans\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\paspc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp\pasps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxm\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscpc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp\rscps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scppc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\scpp\scpps\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tipc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\tip\tips\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udsc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\uds\udss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wssc\api; ..\..\..\..\..\sdk6\sdk\ble_stack\profiles\wss\wsss\api; ..\..\..\..\..\sdk6\sdk\ble_stack\rwble; ..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl; ..\..\..\..\..\sdk6\sdk\common_project_files; ..\..\..\..\..\sdk6\sdk\platform\arch; ..\..\..\..\..\sdk6\sdk\platform\arch\boot; ..\..\..\..\..\sdk6\sdk\platform\arch\compiler; ..\..\..\..\..\sdk6\sdk\platform\arch\ll; ..\..\..\..\..\sdk6\sdk\platform\arch\main; ..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console; ..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto; ..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src; ..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src; ..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api; ..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api; ..\..\..\..\..\sdk6\sdk\platform\driver\adc; ..\..\..\..\..\sdk6\sdk\platform\driver\battery; ..\..\..\..\..\sdk6\sdk\platform\driver\ble; ..\..\..\..\..\sdk6\sdk\platform\driver\dma; ..\..\..\..\..\sdk6\sdk\platform\driver\gpio; ..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc; ..\..\..\..\..\sdk6\sdk\platform\driver\i2c; ..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom; ..\..\..\..\..\sdk6\sdk\platform\driver\pdm; ..\..\..\..\..\sdk6\sdk\platform\driver\reg; ..\..\..\..\..\sdk6\sdk\platform\driver\rtc; ..\..\..\..\..\sdk6\sdk\platform\driver\spi; ..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash; ..\..\..\..\..\sdk6\sdk\platform\driver\spi_hci; ..\..\..\..\..\sdk6\sdk\platform\driver\syscntl; ..\..\..\..\..\sdk6\sdk\platform\driver\systick; ..\..\..\..\..\sdk6\sdk\platform\driver\timer; ..\..\..\..\..\sdk6\sdk\platform\driver\trng; ..\..\..\..\..\sdk6\sdk\platform\driver\uart; ..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec; ..\..\..\..\..\sdk6\sdk\platform\include; ..\..\..\..\..\sdk6\sdk\platform\system_library\include; ..\..\..\..\..\sdk6\sdk\platform\utilities\otp_cs; ..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr; ..\..\..\..\..\sdk6\third_party\hash; ..\..\..\..\..\sdk6\third_party\irng; ..\..\..\..\..\sdk6\third_party\rand
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: codeless_585.bin
  prebuild: scripts\DA1458x_make_icf.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: codeless_585.out
  ILINK.IlinkIcfFile: da14585_586.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration codeless_586 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CODELESS_585; __DA14586__=
  OBJCOPY.OOCOutputFile: codeless_586.bin
  ILINK.IlinkOutputFile: codeless_586.out
configuration codeless_531_01_datapump (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: CODELESS_585; __DA14531__=; __DA14531_01__=; CFG_DATAPMP=; __EXCLUDE_ROM_OTP_CS__=; __EXCLUDE_ROM_RWBLE__=
  OBJCOPY.OOCOutputFile: codeless_531_01_datapump.bin
  prebuild: scripts\DA14531_make_icf.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: codeless_531_01_datapump.out
  ILINK.IlinkIcfFile: da14531.icf
configuration codeless_535 (ARM, debug)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: CODELESS_585; __DA14531__=; __DA14535__=; CFG_DATAPMP=
  OBJCOPY.OOCOutputFile: codeless_535.bin
  prebuild: scripts\DA14535_make_icf.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: codeless_535.out
  ILINK.IlinkIcfFile: da14535.icf
  group (top)
    ../../../../../sdk6/sdk/platform/system_library/output/IAR/: da14531.a da14531_01.a da14535.a da14585_586.a
  group sdk_app
    ../../../../../sdk6/sdk/app_modules/src/app_common/: app.c app_msg_utils.c app_task.c app_utils.c
    ../../../../../sdk6/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_conpar_db/: app_conpar_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_custs/: app_customs.c app_customs_common.c app_customs_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ../../../../../sdk6/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ../../../../../sdk6/sdk/app_modules/src/app_entry/: app_entry_point.c
    ../../../../../sdk6/sdk/app_modules/src/app_events_db/: app_events_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_handlers_db/: app_handlers_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_non_volatile/: app_non_volatile_storage.c
    ../../../../../sdk6/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
  group sdk_app_api
    ../../../../../sdk6/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_handlers_db.h app_mid.h app_msg_utils.h app_non_volatile_storage.h app_security.h app_task.h app_user_config.h
  group sdk_arch
    ../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.c
    ../../../../../sdk6/sdk/platform/arch/main/: arch_hibernation.c arch_main.c arch_rom.c arch_sleep.c arch_system.c jump_table.c
    ../../../../../sdk6/third_party/rand/: chacha20.c
    ../../../../../sdk6/third_party/hash/: hash.c
    ../../../../../sdk6/sdk/platform/core_modules/nvds/src/: nvds.c
    ../../../../../sdk6/sdk/platform/utilities/otp_cs/: otp_cs.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14531/: system_library_531.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14531_01/: system_library_531_01.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14535/: system_library_535.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14585_586/: system_library_585_586.c
  group sdk_arch_api
    ../../../../../sdk6/sdk/platform/arch/: arch_api.h
    ../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.h
    ../../../../../sdk6/sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk6/sdk/platform/arch/compiler/: compiler.h
  group sdk_ble
    ../../../../../sdk6/sdk/platform/core_modules/rf/src/: ble_arp.c rf_531.c rf_585.c
    ../../../../../sdk6/sdk/ble_stack/rwble/: rwble.c
    ../../../../../sdk6/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_boot
    ../../../../../sdk6/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
    ../../../../../sdk6/sdk/platform/arch/boot/IAR/: startup_DA14531.s startup_DA14535.s startup_DA14585_586.s
    ../../../../../sdk6/sdk/platform/arch/boot/: system_DA14531.c system_DA14535.c system_DA14585_586.c
  group sdk_driver
    ../../../../../sdk6/sdk/platform/driver/adc/: adc_531.c adc_58x.c
    ../../../../../sdk6/sdk/platform/driver/battery/: battery.c
    ../../../../../sdk6/sdk/platform/driver/dma/: dma.c
    ../../../../../sdk6/sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc_531.c hw_otpc_58x.c
    ../../../../../sdk6/sdk/platform/driver/i2c/: i2c.c
    ../../../../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../sdk6/sdk/platform/driver/rtc/: rtc.c
    ../../../../../sdk6/sdk/platform/driver/spi/: spi_531.c spi_58x.c
    ../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../sdk6/sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../sdk6/sdk/platform/driver/timer/: timer2.c
    ../../../../../sdk6/sdk/platform/driver/trng/: trng.c
    ../../../../../sdk6/sdk/platform/driver/uart/: uart.c uart_utils.c
    ../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
  group sdk_driver_api
    ../../../../../sdk6/sdk/platform/driver/adc/: adc.h
    ../../../../../sdk6/sdk/platform/driver/battery/: battery.h
    ../../../../../sdk6/sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk6/sdk/platform/driver/i2c/: i2c.h
    ../../../../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../../../../sdk6/sdk/platform/driver/spi/: spi.h
    ../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk6/sdk/platform/driver/timer/: timer2.h
    ../../../../../sdk6/sdk/platform/driver/trng/: trng.h
    ../../../../../sdk6/sdk/platform/driver/uart/: uart.h
    ../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
  group sdk_profiles
    ../../../../../sdk6/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ../../../../../sdk6/sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../sdk6/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
    ../../../../../sdk6/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../sdk6/sdk/ble_stack/profiles/: prf.c prf_utils.c
    ../../../../../sdk6/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
  group user_app
    ../src/: user_at_commands.c user_at_console.c user_baud.c user_bonding_database.c user_cmd_interpreter.c user_cmd_parser.c user_codeless.c user_codeless_env.c user_custs_sps.c user_gap.c user_gatt.c user_handlers.c user_heartbeat.c user_i2c.c user_pwm.c user_security.c user_spi.c user_spi_command_interface.c user_utility_functions.c
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_config_sw_ver.h user_modules_config.h user_periph_setup.h user_profiles_config.h
    ../src/: user_at_commands.h
  group user_config/da14531_config
    ../src/config/: da14531_config_advanced.h da14531_config_basic.h
  group user_config/da14535_config
    ../src/config/: da14535_config_advanced.h da14535_config_basic.h
  group user_config/da14585-6_config
    ../src/config/: da14585_config_advanced.h da14585_config_basic.h
  group user_custom_profile
    ../../common_codeless_files/profiles/CLS/custom_profile/: user_custs1_def_585.c user_custs_config_585.c
  group user_platform
    ../src/platform/: user_periph_setup.c
