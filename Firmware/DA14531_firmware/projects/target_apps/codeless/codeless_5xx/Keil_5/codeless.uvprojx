# Keil uVision project codeless.uvprojx, settings and files
target codeless_585 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x0,0x0) IRAM(0x0,0x0) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: codeless_585 +hex
  AfterMake: fromelf --bincombined --output=".\out_585\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: CODELESS_585, __DA14585__
  c misc: -mthumb -c -include da1458x_config_basic.h -include da1458x_config_advanced.h -include user_config.h -Wno-expansion-to-defined
  c include: ..\..\..\..\..\sdk6\sdk\app_modules\api;..\..\..\..\..\sdk6\sdk\ble_stack\controller\em;..\..\..\..\..\sdk6\sdk\ble_stack\controller\llc;..\..\..\..\..\sdk6\sdk\ble_stack\controller\lld;..\..\..\..\..\sdk6\sdk\ble_stack\controller\llm;..\..\..\..\..\sdk6\sdk\ble_stack\ea\api;..\..\..\..\..\sdk6\sdk\ble_stack\em\api;..\..\..\..\..\sdk6\sdk\ble_stack\hci\api;..\..\..\..\..\sdk6\sdk\ble_stack\hci\src;..\..\..\..\..\sdk6\sdk\ble_stack\host\att;..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attc;..\..\..\..\..\sdk6\sdk\ble_stack\host\att\attm;..\..\..\..\..\sdk6\sdk\ble_stack\host\att\atts;..\..\..\..\..\sdk6\sdk\ble_stack\host\gap;..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapc;..\..\..\..\..\sdk6\sdk\ble_stack\host\gap\gapm;..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt;..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattc;..\..\..\..\..\sdk6\sdk\ble_stack\host\gatt\gattm;..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cc;..\..\..\..\..\sdk6\sdk\ble_stack\host\l2c\l2cm;..\..\..\..\..\sdk6\sdk\ble_stack\host\smp;..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpc;..\..\..\..\..\sdk6\sdk\ble_stack\host\smp\smpm;..\..\..\..\..\sdk6\sdk\ble_stack\profiles;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\anp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\bas\bass\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cpp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\cscp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\custom\custs\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\dis\diss\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findl\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\find\findt\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\hrp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\lan;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\pasp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\prox\proxr\api;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\rscp;..\..\..\..\..\sdk6\sdk\ble_stack\profiles\suota\suotar\api;..\..\..\..\..\sdk6\sdk\ble_stack\rwble;..\..\..\..\..\sdk6\sdk\ble_stack\rwble_hl;..\..\..\..\..\sdk6\sdk\common_project_files;..\..\..\..\..\sdk6\sdk\platform\arch;..\..\..\..\..\sdk6\sdk\platform\arch\boot;..\..\..\..\..\sdk6\sdk\platform\arch\compiler;..\..\..\..\..\sdk6\sdk\platform\arch\ll;..\..\..\..\..\sdk6\sdk\platform\arch\main;..\..\..\..\..\sdk6\sdk\platform\core_modules\arch_console;..\..\..\..\..\sdk6\sdk\platform\core_modules\common\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\crypto;..\..\..\..\..\sdk6\sdk\platform\core_modules\dbg\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\gtl\src;..\..\..\..\..\sdk6\sdk\platform\core_modules\h4tl\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\ke\src;..\..\..\..\..\sdk6\sdk\platform\core_modules\nvds\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\rf\api;..\..\..\..\..\sdk6\sdk\platform\core_modules\rwip\api;..\..\..\..\..\sdk6\sdk\platform\driver\adc;..\..\..\..\..\sdk6\sdk\platform\driver\battery;..\..\..\..\..\sdk6\sdk\platform\driver\ble;..\..\..\..\..\sdk6\sdk\platform\driver\dma;..\..\..\..\..\sdk6\sdk\platform\driver\gpio;..\..\..\..\..\sdk6\sdk\platform\driver\hw_otpc;..\..\..\..\..\sdk6\sdk\platform\driver\i2c;..\..\..\..\..\sdk6\sdk\platform\driver\i2c_eeprom;..\..\..\..\..\sdk6\sdk\platform\driver\pdm;..\..\..\..\..\sdk6\sdk\platform\driver\reg;..\..\..\..\..\sdk6\sdk\platform\driver\rtc;..\..\..\..\..\sdk6\sdk\platform\driver\spi;..\..\..\..\..\sdk6\sdk\platform\driver\spi_flash;..\..\..\..\..\sdk6\sdk\platform\driver\spi_hci;..\..\..\..\..\sdk6\sdk\platform\driver\syscntl;..\..\..\..\..\sdk6\sdk\platform\driver\systick;..\..\..\..\..\sdk6\sdk\platform\driver\timer;..\..\..\..\..\sdk6\sdk\platform\driver\trng;..\..\..\..\..\sdk6\sdk\platform\driver\uart;..\..\..\..\..\sdk6\sdk\platform\driver\wkupct_quadec;..\..\..\..\..\sdk6\sdk\platform\include;..\..\..\..\..\sdk6\sdk\platform\include\CMSIS\5.6.0\Include;..\..\..\..\..\sdk6\sdk\platform\system_library\include;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_cs;..\..\..\..\..\sdk6\sdk\platform\utilities\otp_hdr;..\..\..\..\..\sdk6\third_party\hash;..\..\..\..\..\sdk6\third_party\irng;..\..\..\..\..\sdk6\third_party\rand;..\src;..\src\config;..\..\common_codeless_files\profiles\CLS\custom_profile;..\..\sw_version
  library: MicroLIB
  scatter file: .\scatterfile_585.sct
  link misc: --predefine="-DCODELESS_585" .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=codeless_585_symdef.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\..\..\..\sdk6\sdk\platform\system_library\output\Keil_5\ da14585_586.lib
  group sdk_boot
    ../../../../../sdk6/sdk/platform/arch/boot/: system_DA14585_586.c system_DA14531.c system_DA14535.c
    ../../../../../sdk6/sdk/platform/arch/boot/ARM/: startup_DA14585_586.s startup_DA14531.s startup_DA14535.s
    ../../../../../sdk6/sdk/platform/arch/main/: hardfault_handler.c nmi_handler.c
  group sdk_arch
    ../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.c
    ../../../../../sdk6/sdk/platform/core_modules/nvds/src/: nvds.c
    ../../../../../sdk6/sdk/platform/arch/main/: arch_main.c jump_table.c arch_sleep.c arch_system.c arch_hibernation.c arch_rom.c
    ../../../../../sdk6/third_party/rand/: chacha20.c
    ../../../../../sdk6/third_party/hash/: hash.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14585_586/: system_library_585_586.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14531/: system_library_531.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14531_01/: system_library_531_01.c
    ../../../../../sdk6/sdk/platform/system_library/src/DA14535/: system_library_535.c
    ../../../../../sdk6/sdk/platform/utilities/otp_cs/: otp_cs.c
  group sdk_driver
    ../../../../../sdk6/sdk/platform/driver/syscntl/: syscntl.c
    ../../../../../sdk6/sdk/platform/driver/gpio/: gpio.c
    ../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.c
    ../../../../../sdk6/sdk/platform/driver/battery/: battery.c
    ../../../../../sdk6/sdk/platform/driver/dma/: dma.c
    ../../../../../sdk6/sdk/platform/driver/adc/: adc_58x.c adc_531.c
    ../../../../../sdk6/sdk/platform/driver/uart/: uart.c
    ../../../../../sdk6/sdk/platform/driver/spi/: spi_58x.c spi_531.c
    ../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.c
    ../../../../../sdk6/sdk/platform/driver/i2c/: i2c.c
    ../../../../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc_58x.c hw_otpc_531.c
    ../../../../../sdk6/sdk/platform/driver/trng/: trng.c
    ../../../../../sdk6/sdk/platform/driver/rtc/: rtc.c
    ../../../../../sdk6/sdk/platform/driver/timer/: timer1.c timer2.c
  group sdk_ble
    ../../../../../sdk6/sdk/platform/core_modules/rf/src/: rf_585.c ble_arp.c rf_531.c
    ../../../../../sdk6/sdk/ble_stack/rwble/: rwble.c
    ../../../../../sdk6/sdk/platform/core_modules/rwip/src/: rwip.c
  group sdk_profiles
    ../../../../../sdk6/sdk/ble_stack/profiles/: prf.c prf_utils.c
    ../../../../../sdk6/sdk/ble_stack/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../sdk6/sdk/ble_stack/profiles/suota/suotar/src/: suotar.c suotar_task.c
    ../../../../../sdk6/sdk/ble_stack/host/att/attm/: attm_db_128.c
    ../../../../../sdk6/sdk/ble_stack/profiles/custom/: custom_common.c
    ../../../../../sdk6/sdk/ble_stack/profiles/custom/custs/src/: custs1.c custs1_task.c custs2.c custs2_task.c
  group sdk_app
    ../../../../../sdk6/sdk/app_modules/src/app_default_hnd/: app_default_handlers.c
    ../../../../../sdk6/sdk/app_modules/src/app_common/: app.c app_task.c app_msg_utils.c app_utils.c
    ../../../../../sdk6/sdk/app_modules/src/app_sec/: app_security.c app_security_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_entry/: app_entry_point.c
    ../../../../../sdk6/sdk/app_modules/src/app_easy/: app_easy_msg_utils.c app_easy_security.c app_easy_timer.c
    ../../../../../sdk6/sdk/app_modules/src/app_diss/: app_diss.c app_diss_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_bass/: app_bass.c app_bass_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_custs/: app_customs.c app_customs_task.c app_customs_common.c
    ../../../../../sdk6/sdk/app_modules/src/app_findme/: app_findme.c app_findme_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_proxr/: app_proxr.c app_proxr_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_suotar/: app_suotar.c app_suotar_task.c
    ../../../../../sdk6/sdk/app_modules/src/app_bond_db/: app_bond_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_handlers_db/: app_handlers_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_non_volatile/: app_non_volatile_storage.c
    ../../../../../sdk6/sdk/app_modules/src/app_events_db/: app_events_db.c
    ../../../../../sdk6/sdk/app_modules/src/app_conpar_db/: app_conpar_db.c
  group sdk_driver_api
    ../../../../../sdk6/sdk/platform/driver/syscntl/: syscntl.h
    ../../../../../sdk6/sdk/platform/driver/gpio/: gpio.h
    ../../../../../sdk6/sdk/platform/driver/wkupct_quadec/: wkupct_quadec.h
    ../../../../../sdk6/sdk/platform/driver/battery/: battery.h
    ../../../../../sdk6/sdk/platform/driver/dma/: dma.h
    ../../../../../sdk6/sdk/platform/driver/adc/: adc.h adc_58x.h adc_531.h
    ../../../../../sdk6/sdk/platform/driver/uart/: uart.h uart_utils.h
    ../../../../../sdk6/sdk/platform/driver/spi/: spi.h spi_58x.h spi_531.h
    ../../../../../sdk6/sdk/platform/driver/spi_flash/: spi_flash.h
    ../../../../../sdk6/sdk/platform/driver/i2c/: i2c.h
    ../../../../../sdk6/sdk/platform/driver/i2c_eeprom/: i2c_eeprom.h
    ../../../../../sdk6/sdk/platform/driver/hw_otpc/: hw_otpc.h hw_otpc_58x.h hw_otpc_531.h
    ../../../../../sdk6/sdk/platform/driver/trng/: trng.h
    ../../../../../sdk6/sdk/platform/driver/rtc/: rtc.h
    ../../../../../sdk6/sdk/platform/driver/timer/: timer1.h timer2.h
  group sdk_app_api
    ../../../../../sdk6/sdk/app_modules/api/: app.h app_api.h app_callback.h app_default_handlers.h app_easy_gap.h app_easy_msg_utils.h app_easy_security.h app_easy_timer.h app_entry_point.h app_mid.h app_msg_utils.h app_security.h app_task.h app_user_config.h app_handlers_db.h app_non_volatile_storage.h
  group sdk_arch_api
    ../../../../../sdk6/sdk/platform/arch/main/: arch_wdg.h
    ../../../../../sdk6/sdk/platform/arch/: arch_api.h
    ../../../../../sdk6/sdk/platform/core_modules/arch_console/: arch_console.h
    ../../../../../sdk6/sdk/platform/arch/compiler/: compiler.h
  group user_config
    ../src/config/: da1458x_config_advanced.h da1458x_config_basic.h user_callback_config.h user_config.h user_config_sw_ver.h user_modules_config.h user_periph_setup.h user_profiles_config.h da14585_config_basic.h da14585_config_advanced.h da14531_config_basic.h da14531_config_advanced.h da14535_config_basic.h da14535_config_advanced.h
    ../src/: user_at_commands.h
  group user_custom_profile
    ../../common_codeless_files/profiles/CLS/custom_profile/: user_custs_config_585.c user_custs1_def_585.c
  group user_platform
    ../src/platform/: user_periph_setup.c
  group user_app
    ../src/: user_at_console.c user_at_commands.c user_baud.c user_bonding_database.c user_cmd_interpreter.c user_cmd_parser.c user_codeless.c user_codeless_env.c user_custs_sps.c user_gap.c user_gatt.c user_handlers.c user_heartbeat.c user_i2c.c user_pwm.c user_security.c user_spi.c user_spi_command_interface.c user_utility_functions.c
target codeless_586 (6180000::V6.18::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: codeless_586 +hex
  AfterMake: fromelf --bincombined --output=".\out_586\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: CODELESS_585, __DA14586__
  c misc: as above
  c include: as above
  library: MicroLIB
  scatter file: .\scatterfile_585.sct
  link misc: --predefine="-DCODELESS_585"  .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14585_symbols.txt  --symdefs=codeless_585_symdef.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\..\..\..\sdk6\sdk\platform\system_library\output\Keil_5\ da14585_586.lib
target codeless_531_datapump (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: codeless_531_datapump +hex
  AfterMake: fromelf --bincombined --output=".\out_531\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: CODELESS_585, __DA14531__,CFG_DATAPMP
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatterfile_531.sct
  link misc: --predefine="-DCODELESS_585"   .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14531_symbols.txt  --symdefs=codeless_531_symdef.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\..\..\..\sdk6\sdk\platform\system_library\output\Keil_5\ da14531.lib
target codeless_531_standalone (6240000::V6.24::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: codeless_531_standalone +hex
  AfterMake: fromelf --bincombined --output=".\out_531\@L.bin"  "!L"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CODELESS_585, __DA14531__,CFG_STNDALN
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatterfile_531.sct
  link misc: as above
target codeless_531_set_two_standalone (6240000::V6.24::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: codeless_531_set_two_standalone +hex
  AfterMake: fromelf --bincombined --output=".\out_531\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CODELESS_585, __DA14531__,CFG_STNDALN_SET_TWO
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatterfile_531.sct
  link misc: as above
target codeless_531_01_datapump (6240000::V6.24::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: codeless_531_01_datapump +hex
  AfterMake: fromelf --bincombined --output=".\out_531_01\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CODELESS_585, __DA14531__,CFG_DATAPMP,__DA14531_01__ __EXCLUDE_ROM_OTP_CS__ __EXCLUDE_ROM_RWBLE__
  c misc: -mthumb -c -include da1458x_config_basic.h -include da1458x_config_advanced.h --include user_config.h -Wno-expansion-to-defined
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatterfile_531_01.sct
  link misc: --predefine="-DCODELESS_585"   .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14531_01_symbols.txt  --symdefs=codeless_531_symdef.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\..\..\..\sdk6\sdk\platform\system_library\output\Keil_5\ da14531_01.lib
target codeless_535 (6180000::V6.18::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: codeless_535 +hex
  AfterMake: fromelf --bincombined --output=".\out_535\@L.bin"  "!L"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: CODELESS_585, __DA14531__,CFG_DATAPMP __DA14535__
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\scatterfile_535.sct
  link misc: --predefine="-DCODELESS_585"   .\..\..\..\..\..\sdk6\sdk\common_project_files\misc\da14535_symbols.txt  --symdefs=codeless_535_symdef.txt --any_placement=best_fit --datacompressor off
--userlibpath ..\..\..\..\..\sdk6\sdk\platform\system_library\output\Keil_5\ da14535.lib
